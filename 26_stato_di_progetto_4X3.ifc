Properties of the parts of a building model (IFC4X3_ADD2)

# File
File name: 26_stato_di_progetto_4X3.ifc
Time: 2025-04-23T09:29:14+02:00
Written by: IfcOpenShell 0.8.3-alpha250421
Made in: Bonsai 0.8.3-alpha250421-5c4f157

# IfcBuildingElementProxy (21)
Name | In | String Name | Code 1 | Code 2 | Layer Index | Material
asse_piede_pennello/R3/R4/1/PP - Tappeti zavorrati | Piede pennello | asse_piede_pennello | R3 | R4 | 1 | PP - Tappeti zavorrati
asse_piede_pennello/C.L./R1/2/PP - Pietrame 300-1000 kg | Piede pennello | asse_piede_pennello | C.L. | R1 | 2 | PP - Pietrame 300-1000 kg
asse_piede_pennello/R1/R2/1/PP - Tappeti zavorrati | Piede pennello | asse_piede_pennello | R1 | R2 | 1 | PP - Tappeti zavorrati
asse_piede_pennello/R1/R2/2/PP - Burghe | Piede pennello | asse_piede_pennello | R1 | R2 | 2 | PP - Burghe
asse_piede_pennello/R1/R2/3/PP - Pietrame 300-1000 kg | Piede pennello | asse_piede_pennello | R1 | R2 | 3 | PP - Pietrame 300-1000 kg
asse_piede_pennello/R2/R3/1/PP - Tappeti zavorrati | Piede pennello | asse_piede_pennello | R2 | R3 | 1 | PP - Tappeti zavorrati
asse_pennello/C.L./LST/3/CP - Pietrame 300-1000 kg | Corpo pennello | asse_pennello | C.L. | LST | 3 | CP - Pietrame 300-1000 kg
asse_pennello/LST/LAT/1/CP - Pietrame 300-1000 kg | Corpo pennello | asse_pennello | LST | LAT | 1 | CP - Pietrame 300-1000 kg
asse_pennello/RAFS/RAFR/1/CP - Pietrame 300-1000 kg | Corpo pennello | asse_pennello | RAFS | RAFR | 1 | CP - Pietrame 300-1000 kg
asse_pennello/RAT/RAFS/1/CP - Pietrame 300-1000 kg | Corpo pennello | asse_pennello | RAT | RAFS | 1 | CP - Pietrame 300-1000 kg
asse_pennello/LAT/LAD/1/CP - Pietrame 300-1000 kg | Corpo pennello | asse_pennello | LAT | LAD | 1 | CP - Pietrame 300-1000 kg
asse_pennello/C.L./RST/2/ST - Misto stabilizzato | Strada | asse_pennello | C.L. | RST | 2 | ST - Misto stabilizzato
asse_pennello/C.L./LST/2/ST - Misto stabilizzato | Strada | asse_pennello | C.L. | LST | 2 | ST - Misto stabilizzato
asse_piede_pennello/C.L./R1/1/PP - Burghe | Piede pennello | asse_piede_pennello | C.L. | R1 | 1 | PP - Burghe
asse_pennello/LAD/LAB/1/TA - Pietrame 300-1000 kg | Corpo pennello | asse_pennello | LAD | LAB | 1 | TA - Pietrame 300-1000 kg
asse_pennello/C.L./RST/1/ST - Tout Venant | Strada | asse_pennello | C.L. | RST | 1 | ST - Tout Venant
asse_pennello/C.L./LST/1/ST - Tout Venant | Strada | asse_pennello | C.L. | LST | 1 | ST - Tout Venant
asse_pennello/C.L./RST/3/CP - Pietrame 300-1000 kg | Corpo pennello | asse_pennello | C.L. | RST | 3 | CP - Pietrame 300-1000 kg
asse_pennello/RST/RAT/1/CP - Pietrame 300-1000 kg | Corpo pennello | asse_pennello | RST | RAT | 1 | CP - Pietrame 300-1000 kg
asse_piede_pennello/R2/R3/2/PP - Burghe | Piede pennello | asse_piede_pennello | R2 | R3 | 2 | PP - Burghe
Terreno | Lanca
